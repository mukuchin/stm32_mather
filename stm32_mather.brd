# Repository mukuchin/stm32_mather

## EAGLE design stm32_mather.brd

Parts:
C1, C8: 4.7u; C1608
C2: 1u; C1608
C3: 0.22u; C2012
C4, C9, C10, C11, C12, C13, C14, C15: 0.1u; C1608
C5: 4.7u; C2012
C6: 470p; C1608
C7: 10u; C2012
C16: C-EUC1608; C1608
IC1: CH340E; MSOP10
JP1: PINHD-1X2; 1X02
LED1, LED2: 1608LED; 1608
MCU1: STM32F446; LQFP64-2
OSC1: 12M; CSTNE#
R1: 33k; 1608
R2: 20k; 1608
R3: 330; 1608
R4, R13: 120; 1608
R5: 10k>R; 1608
R6, R7: 5.1k; 1608
R8: 1k; 1608
R9, R10, R11, R12, R14, R15, R16: 10k; 1608
R_I1: R_SHUGOU; 0603X4RESISTOR
U$1: ARDUINO-PRO-MINI; ARDUINO_PRO_MINI
U$2, U$3, U$4, U$5, U$6, U$7: BOX10PBOX10PIN-MESU; BOX10P-MESU
U$8: BOX10PBOX10P-L; BOX10P-L
U$9: YUROBLOCK3
U$10: NJM11100; SOT23-6
U$11: 2SC5964; PCP
U$12: TAKUTOSUITTI2
U$13: MCP2562MCP2561-SN; SOIC8
U$14: FDC6305; SSOT6
U$15: RGB_LED
U$22: BOX14P; CON_HEDA14P_1.27
USB1: USB_TYPE_C

Connections:
B_LED: MCU1.35, R_I1.6
CANH: R4.2, R13.1, U$2.6, U$3.6, U$4.6, U$5.6, U$6.6, U$7.6, U$8.P$6, U$13.P$7 (CANH)
CANL: JP1.1, R4.1, U$2.5, U$3.5, U$4.5, U$5.5, U$6.5, U$7.5, U$8.P$5, U$13.P$6 (CANL)
CANRX: MCU1.44, U$13.P$4 (RXD)
CANTX: MCU1.45, U$13.P$1 (TXD)
ERROR: MCU1.33 (33_PB12<), R_I1.8
GND: C1.2, C3.2, C4.2, C5.2, C7.2, C9.2, C13.1, C14.2, C15.2, C16.2, IC1.3 (3_GND), LED1.K, LED2.K, MCU1.31 (31_VSS), OSC1.P$2 (GND), R2.1, R6.1, R7.1, R16.2, U$2.3, U$2.4, U$3.3, U$3.4, U$4.3, U$4.4, U$5.3, U$5.4, U$6.3, U$6.4, U$7.3, U$7.4, U$8.P$7, U$8.P$8, U$9.P$1, U$10.2 (PIN2_GND), U$13.P$2 (VSS), U$15.B_A, U$15.G_A, U$15.R_A, U$22.5, U$22.7, U$22.11, USB1.A1_B12 (A1_B12_GND), USB1.B1_A12 (A12_B1_GND)
G_LED: MCU1.34, R_I1.7
JTCK: MCU1.49 (PA49_PA14<), U$22.6
JTDI: MCU1.50 (50_PA15>), U$22.10
JTDO: MCU1.55 (55_PB3<), U$22.8
JTMS: MCU1.46 (46_PA13>), U$22.4
unnamed: C6.2, R1.1, R2.2, U$10.5 (PIN5_VADJ)
unnamed: C4.1, U$10.3 (PIN3_NOIS?)
unnamed: C5.1, C6.1, U$10.4 (PIN4_VOUT), U$11.1 (B)
unnamed: C1.1, MCU1.30 (30_VCAP_1)
unnamed: C9.1, MCU1.32 (32_VDD)
unnamed: OSC1.P$1 (IN), R3.1
unnamed: C2.1, MCU1.12 (12_VSSA)
unnamed: C8.1, MCU1.64 (64_VDD)
unnamed: C8.2, MCU1.63 (63_VSS)
unnamed: R_I1.1, U$15.R_K
unnamed: MCU1.5 (5_PH0_OSCIN), OSC1.P$3 (OUT)
unnamed: MCU1.6 (6_PH1_OSCOUT), R3.2
unnamed: C12.2, MCU1.18 (18_VSS)
unnamed: C12.1, MCU1.19 (19_VDD)
unnamed: C11.1, MCU1.47 (47_VSS)
unnamed: C11.2, MCU1.48 (48_VDD)
unnamed: IC1.1 (1_UD+), USB1.A6 (A6_DP1), USB1.B6 (B6_DP2)
unnamed: IC1.2 (2_UD-), USB1.A7 (A7_DN1), USB1.B7 (B7_DN2)
unnamed: R5.1, U$13.P$8 (STBY)
unnamed: R7.2, USB1.A5 (A5_CC1)
unnamed: R6.2, USB1.B5 (B5_CC2)
unnamed: IC1.6 (6_TNOU), R8.1
unnamed: LED1.A, R8.2
unnamed: C15.1, IC1.10 (10_V3)
unnamed: IC1.4 (4_RTS#), IC1.5 (5_CTS#)
unnamed: IC1.8 (8_TXD), R10.2, U$14.2 (PIN2_S2)
unnamed: JP1.2, R13.2
unnamed: IC1.9 (9_RXD), R9.1, U$14.5 (PIN5_S1)
unnamed: R_I1.2, U$15.G_K
unnamed: C2.2, C10.2, MCU1.13 (13_VDDA), U$12.P$1 (PIN1)
unnamed: R_I1.3, U$15.B_K
unnamed: LED2.A, R_I1.4
unnamed: MCU1.60 (60_BOOT0), R16.1
NRST: C10.1, MCU1.7 (7_NRST), U$12.P$2 (PIN2), U$22.12
RX: MCU1.17 (17_PA3>), U$22.13
SCL: MCU1.61 (61_PB8<), R12.2, U$1.SCL
SDA: MCU1.62 (62_PB9>), R11.2, U$1.SDA
TX: MCU1.16, U$22.14
USART1_RX: MCU1.59 (59_PB7>), R14.1, U$14.4 (PIN4_D2)
USART1_TX: MCU1.58, R15.1, U$14.6 (PIN6_D1)
V3.3: C7.1, C14.1, MCU1.1 (1_VBAT), R1.2, R11.1, R12.1, R14.2, R15.2, R_I1.5, U$11.3 (E), U$13.P$5 (VIO), U$22.3
V3.3_AR: U$1.21 (21_VCC)
V5: C3.1, C13.2, C16.1, IC1.7 (7_VCC), R5.2, R9.2, R10.1, U$1.24 (24_RAW), U$2.1, U$2.2, U$3.1, U$3.2, U$4.1, U$4.2, U$5.1, U$5.2, U$6.1, U$6.2, U$7.1, U$7.2, U$8.P$9, U$8.P$10, U$9.P$2, U$10.1 (PIN1_CON), U$10.6 (PIN6_VIN), U$11.2 (C), U$11.2@2 (C), U$13.P$3 (VDD), U$14.1 (PIN1_G1), U$14.3 (PIN3_G2), USB1.A4_B9 (A4_B9_VBUS), USB1.B4_A9 (A9_B4_VBUS)
V12: U$2.9, U$2.10, U$3.9, U$3.10, U$4.9, U$4.10, U$5.9, U$5.10, U$6.9, U$6.10, U$7.9, U$7.10, U$8.P$1, U$8.P$2, U$9.P$3

Notes on the sheet:
片方向の通信だから分圧か抵抗と高速ダイオードでレベル変換するんでいい気がする

Board: 2 copper layers, 56 parts (6 on the bottom side), 55 nets, no tracks yet.

## Commit log

2020-11-19 stm32仕様can通信系マザボ 回路図はできた、基板図はまだ
2020-11-19 ledとか追加した
2020-11-19 bootピンの設定をした
